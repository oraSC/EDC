# Keil uVision project EDC.uvprojx, settings and files
target EDC (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,SVGA
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\motor;..\HARDWARE\lcd;..\HARDWARE\DCMI;..\HARDWARE\OV2640;..\HARDWARE\PID;..\HARDWARE\usart3;..\HARDWARE\init
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/lcd/: lcd.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/OV2640/: sccb.c ov2640.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/usart3/: usart3.c
    ../HARDWARE/init/: init.c
  group README
    ../: readme.txt
